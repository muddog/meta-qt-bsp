FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append = " file://0050-Add-the-imxvideoconvert_pxp-support-for-CSC-process.patch "
