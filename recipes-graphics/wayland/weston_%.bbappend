FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

FILES_${PN} += "${bindir}/weston-calibrator"
